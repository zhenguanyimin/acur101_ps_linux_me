SRC_URI += "file://user_2023-02-14-11-23-00.cfg \
            file://user_2023-02-14-11-50-00.cfg \
            file://user_2023-03-14-10-59-00.cfg \
            file://user_2023-03-14-11-07-00.cfg \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

