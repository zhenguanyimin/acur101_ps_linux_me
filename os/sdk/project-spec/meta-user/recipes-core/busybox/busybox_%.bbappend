SRC_URI += "file://user_2023-10-17-08-43-00.cfg"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

