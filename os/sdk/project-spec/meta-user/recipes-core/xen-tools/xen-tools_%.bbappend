SRC_URI += "file://0001-console-modify-ratelimit.patch \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

